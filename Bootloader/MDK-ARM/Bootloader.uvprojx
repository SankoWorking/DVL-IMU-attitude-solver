# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../../Core/Inc;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Inc
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ../../MDK-ARM/: startup_stm32h743xx.s
  group Bootloader/Core
    ../Core/Src/: main.c stm32h7xx_it.c system_stm32h7xx_boot.c boot_flash.c
  group Bootloader/USB_DEVICE
    ../USB_DEVICE/App/: usb_device.c boot_cdc_if.c boot_msc_storage.c usbd_desc.c
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_exti.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Src/: usbd_composite_builder.c
software components: CMSIS:CORE 4.3.0
